Commit message: minor fix to baxter model

File: models/baxter/baxter_new.urdf (robot description, URDF)
Before this commit: robot baxter, 57 links, 56 joints
Joints:
- joint l_gripper_r_finger_joint: axis 0 -1 0 -> 0 1 0
- joint r_gripper_r_finger_joint: axis 0 -1 0 -> 0 1 0
